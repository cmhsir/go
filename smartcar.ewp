# IAR project smartcar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smartcar.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: common\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c
  group bsp
    ./: bsp.c bsp.h
  group commn
    common/: _printf.c _printf.h crt0.s MK40N512VMD100.h MK60N512VMD100.h vectors.c vectors.h
    ./: K60_datatype.h
  group Driver
    ./: ADC.c ADC.h common.c DMA.c DMA.h exti.c exti.h flash.c flash.h GPIO.c GPIO.h iic.c iic.h locatingEye.c MCG.c MCG.h oled.c oled.h PIT0.c PIT0.h PWM.c PWM.h sccb.c sccb.h

<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>bsp</name>
    <file>
      <name>$PROJ_DIR$\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp.h</name>
    </file>
  </group>
  <group>
    <name>commn</name>
    <file>
      <name>$PROJ_DIR$\common\_printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\_printf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\K60_datatype.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\MK40N512VMD100.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\MK60N512VMD100.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\vectors.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\vectors.h</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\ADC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ADC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\DMA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\DMA.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\GPIO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\GPIO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\iic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\iic.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\locatingEye.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MCG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MCG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\oled.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\oled.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PIT0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PIT0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PWM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PWM.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sccb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\sccb.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


